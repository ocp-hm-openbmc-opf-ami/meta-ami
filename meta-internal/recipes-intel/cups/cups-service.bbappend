FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRCREV = "c17c6f946dc9b759be19b59644e278dfe98e7659"
SRC_URI += "file://0001-Add-Current-PowerState-monitoring-before-CPU-detecti.patch"
