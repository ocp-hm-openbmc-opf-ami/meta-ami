OBMC_IMAGE_EXTRA_INSTALL:append = " \
                                  ipmitool \
                                  phosphor-sel-logger \
                                 "
