FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

DEPENDS:append = " virtual/phosphor-led-manager-config-native"
