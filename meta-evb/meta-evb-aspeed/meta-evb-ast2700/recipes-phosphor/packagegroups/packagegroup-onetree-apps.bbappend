#Removed default-fru package from package group, due to this package removed from SDkv9.05   

RDEPENDS:${PN}-fru:remove = " default-fru"
