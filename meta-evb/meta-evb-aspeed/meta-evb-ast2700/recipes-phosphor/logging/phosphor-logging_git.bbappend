# Workaround
do_collect_spdx_deps[nostamp] = "1"
