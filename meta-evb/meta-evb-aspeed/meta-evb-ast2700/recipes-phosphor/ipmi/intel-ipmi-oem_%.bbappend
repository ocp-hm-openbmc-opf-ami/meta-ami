FILESEXTRAPATHS:append := ":${THISDIR}/${PN}"

EXTRA_OEMESON += " -Ddisable-special-mode=true"
