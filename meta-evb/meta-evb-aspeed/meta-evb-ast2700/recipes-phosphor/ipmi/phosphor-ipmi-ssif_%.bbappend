PROVIDES:remove = "virtual/obmc-host-ipmi-hw"
RPROVIDES:${PN}:remove = "virtual-obmc-host-ipmi-hw"
RRECOMMENDS:${PN}:remove = "phosphor-ipmi-host"
