FILESEXTRAPATHS:append := ":${THISDIR}/${PN}"

#SRC_URI:append = " file://0001-Update-to-vue-5.0.8.patch "

#0002-Use-aspeed-s-novnc-fork.patch
#0003-revert-limit-to-on-chunk.patch
