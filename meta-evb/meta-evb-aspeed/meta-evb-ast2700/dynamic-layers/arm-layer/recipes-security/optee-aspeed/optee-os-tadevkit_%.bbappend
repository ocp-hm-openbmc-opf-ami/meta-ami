require optee-os-helper.inc
