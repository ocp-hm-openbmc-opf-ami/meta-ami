FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append:cypress-s25hx = " file://0001-support-2bit-ecc.patch"
