FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
	file://0001-blk-allow-to-define-the-default-block-size-as-env-va.patch \
"
