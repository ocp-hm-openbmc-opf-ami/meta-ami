require bootmcu-fw.inc
require recipes-bsp/u-boot/u-boot-common-aspeed-sdk_${PV}.inc

