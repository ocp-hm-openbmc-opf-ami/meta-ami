# AST2600 DCSCM and AST2700 DCSCM disable ssifbridge service by default.
SYSTEMD_AUTO_ENABLE ?= "disable"
