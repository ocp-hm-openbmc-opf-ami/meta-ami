PACKAGECONFIG:remove = "log-alarm"
