PACKAGECONFIG:remove = "intelcpusensor "
