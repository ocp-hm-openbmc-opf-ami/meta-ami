
RDEPENDS:${PN}-settings = "settings"

RDEPENDS:${PN}-leds:remove = "phosphor-led-manager-faultmonitor"
RDEPENDS:${PN}-leds:remove = "phosphor-led-manager"
