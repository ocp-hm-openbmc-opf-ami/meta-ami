SNOOP_DEVICE = "npcm-bpc0"
