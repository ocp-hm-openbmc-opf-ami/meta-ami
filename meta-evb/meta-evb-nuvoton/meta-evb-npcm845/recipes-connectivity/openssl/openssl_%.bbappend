EXTRA_OECONF:append = " enable-legacy "
PACKAGES =+ " enable-legacy "
