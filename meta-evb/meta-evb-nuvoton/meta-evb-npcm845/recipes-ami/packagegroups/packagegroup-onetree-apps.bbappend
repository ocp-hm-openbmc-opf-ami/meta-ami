RDEPENDS:${PN}-thermal-mgnt:append:s997 = " phosphor-virtual-sensor"
