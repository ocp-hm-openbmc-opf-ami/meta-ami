FILESEXTRAPATHS:prepend := "${THISDIR}/settings:"

SRC_URI += " file://0001-Create-object-path-for-power-restore-policy-one-time.patch "
