SNOOP_DEVICE = ""