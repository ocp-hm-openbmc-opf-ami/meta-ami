FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += " file://0001-Disable-Active-and-BackupImage-checkboxes-f.patch "
