EXTRA_OEMAKE:append = " ARCH=ARCH_ARM"
