FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

ATF_BINARY = "bl31-${ATF_PLATFORM}.bin"
FIT_LOADABLES += "${ATF_BINARY}"
