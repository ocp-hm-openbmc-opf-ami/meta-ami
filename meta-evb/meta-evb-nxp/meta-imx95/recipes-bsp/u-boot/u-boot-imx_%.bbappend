# Allow U-Boot to search this layer’s files directory
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
