BOOST_LIBS:append:evb-imx95 = " serialization filesystem atomic"