SRC_URI:append:evb-imx95 = " file://merge_yamls.py"