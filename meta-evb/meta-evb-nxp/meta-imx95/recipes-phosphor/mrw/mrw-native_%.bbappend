FILESEXTRAPATHS:prepend:evb-imx93 := "${THISDIR}/${PN}:"
SRC_URI:append:evb-imx95 = " file://evb-imx95.xml.patch.xml"
