FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
#SRC_URI += " \
#        file://0002-imx-imx93_frdm-Add-basic-board-support.patch \
#	"
# u-boot-imx_2025.04.bbappend
