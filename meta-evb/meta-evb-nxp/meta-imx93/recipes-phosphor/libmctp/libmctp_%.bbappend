PACKAGECONFIG[pcap] = "-Dcapture=enabled,-Dcapture=disabled,libpcap,"
PACKAGECONFIG[systemd] = ""