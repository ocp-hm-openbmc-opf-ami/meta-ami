# Make phosphor-state-manager satisfy the OpenBMC virtuals
RPROVIDES:${PN} += "virtual-obmc-system-mgmt virtual-obmc-chassis-mgmt virtual-obmc-host-mgmt"