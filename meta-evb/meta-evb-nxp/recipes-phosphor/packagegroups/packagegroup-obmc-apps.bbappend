#RDEPENDS:${PN}-inventory:append:nxp = " openpower-occ-control id-button"
RDEPENDS:${PN}-extras:append:nxp = " webui-vue phosphor-image-signing"
