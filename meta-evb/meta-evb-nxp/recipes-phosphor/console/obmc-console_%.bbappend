FILESEXTRAPATHS:prepend:nxp := "${THISDIR}/${PN}:"
