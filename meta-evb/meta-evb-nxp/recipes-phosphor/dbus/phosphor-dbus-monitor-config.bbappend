PHOSPHOR_DBUS_MONITOR_CONFIGS:append = " host-reset"