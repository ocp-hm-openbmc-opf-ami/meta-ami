FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += " file://CVE-2026-27135.patch "
