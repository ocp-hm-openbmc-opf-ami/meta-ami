FILESEXTRAPATHS:append := "${THISDIR}/${PN}:"

# CVE-2025-1390 is fixed in libcap 2.76.
