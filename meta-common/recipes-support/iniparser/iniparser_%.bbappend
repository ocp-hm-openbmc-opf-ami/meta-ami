FILESEXTRAPATHS:append := "${THISDIR}/${PN}:"

SRC_URI += "file://CVE-2025-0633.patch"

