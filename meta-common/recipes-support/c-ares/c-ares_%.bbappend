FILESEXTRAPATHS:append := "${THISDIR}/${PN}:"

SRC_URI += " \
        file://0001-CVE-2025-62408.patch \
        file://0001-CVE-2026-33630.patch \
        "

