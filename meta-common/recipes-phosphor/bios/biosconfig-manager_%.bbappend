# Enable downstream autobump
# The URI is required for the autobump script but keep it commented
# to not override the upstream value
# SRC_URI = "git://github.com/openbmc/bios-settings-mgr;branch=master;protocol=https"
SRCREV = "9ace6ac55b6cad569ddf8bf02edc1504ddf7677f"

