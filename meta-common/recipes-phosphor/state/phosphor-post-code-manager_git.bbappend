SRCREV = "a27519e987a8341585e50913930862825c48cd26"

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://0001-Add-Previous-and-Current-PostCode-Support.patch \
"
