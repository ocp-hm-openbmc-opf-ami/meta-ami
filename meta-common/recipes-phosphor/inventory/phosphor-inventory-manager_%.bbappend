SRC_URI:append = " file://0001-Support-variant-type-properties.patch"
SRCREV = "149407b34704a048191aa8d0eb83d4ffdcaf24c8"

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

