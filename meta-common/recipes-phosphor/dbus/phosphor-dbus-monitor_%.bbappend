FILESEXTRAPATHS:append := "${THISDIR}/${PN}:"

SRC_URI += " \
           file://0001-Added-changes-for-snmp-binding-variable.patch \
           "

