FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRCREV = "11c35e133e61f4b31e0cf629d62d3a066b7e2970"

SRC_URI += "\
	    file://0047-patch_err_fix.patch\
	   "
	   
           


