FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " \
    file://0001-Fix-for-Uninitialized-Variable.patch \
    "

