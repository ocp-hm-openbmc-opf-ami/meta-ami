FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI += "\
	       file://0002-Board-Mfg-date-printf-function-modified.patch \
	   "








