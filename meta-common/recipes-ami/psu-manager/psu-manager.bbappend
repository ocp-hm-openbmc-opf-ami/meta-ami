FILESEXTRAPATHS:prepend := "${THISDIR}/psu-manager:"

SRC_URI:append = " file://0001-migration-journal-logs-to-dbus-psu-manager.patch"
