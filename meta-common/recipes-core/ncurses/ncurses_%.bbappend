FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += " file://CVE-2025-6141.patch "
