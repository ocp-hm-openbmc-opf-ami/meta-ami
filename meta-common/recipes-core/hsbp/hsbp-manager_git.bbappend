FILESEXTRAPATHS:prepend := "${THISDIR}/hsbp-manager:"

SRC_URI:append = "file://0001-migrate-journal-events-to-dbus-hsbp.patch"
