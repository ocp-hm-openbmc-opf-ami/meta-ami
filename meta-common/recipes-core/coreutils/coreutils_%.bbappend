FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += " file://CVE-2025-5278.patch "
