IMAGE_INSTALL:append = " \
        io-app \
        lpc-cmds \
        beeper-test \
        "
