FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

DEFAULT_TIMEZONE = "UTC"
