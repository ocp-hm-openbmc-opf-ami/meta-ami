# The URI is required for the autobump script but keep it commented
# to not override the upstream value
# SRC_URI = "git://github.com/openbmc/sdbusplus;branch=master;protocol=https"
#SRCREV = "f23e4d4127cc2d875f612ba12a0ae8bc5337f499"

