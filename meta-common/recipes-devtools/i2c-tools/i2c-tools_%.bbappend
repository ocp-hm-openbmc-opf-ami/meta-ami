FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI =+ "file://0003-Added-semaphore-support.patch"
