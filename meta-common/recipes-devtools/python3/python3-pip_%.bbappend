FILESEXTRAPATHS:append := "${THISDIR}/${PN}:"
SRC_URI += " \
           file://CVE-2026-1703.patch \
           "
