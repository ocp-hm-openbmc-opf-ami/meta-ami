FILESEXTRAPATHS:prepend := "${THISDIR}/linux-aspeed:"
SRC_URI += "file://0001-ARM-dts-tiogapass-enable-uart-routing.patch"