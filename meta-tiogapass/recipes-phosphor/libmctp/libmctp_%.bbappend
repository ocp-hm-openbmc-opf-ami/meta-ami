# Clear autotools-style PACKAGECONFIG args for meson builds.
PACKAGECONFIG[systemd] = ""
PACKAGECONFIG[pcap] = ""
