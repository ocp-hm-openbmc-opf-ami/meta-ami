PACKAGECONFIG:remove:devkit-npcm845 = " \
    exitairtempsensor \
    mcutempsensor \
    psusensor \
"
