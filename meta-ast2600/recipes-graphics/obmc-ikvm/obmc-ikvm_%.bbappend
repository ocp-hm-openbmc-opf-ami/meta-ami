FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

# Todo: Commented out to avoid build failure
#SRC_URI += " \
#    file://0001-Enable-per-frame-CRC-calculation-option-to-save-netw.patch \
#    "
