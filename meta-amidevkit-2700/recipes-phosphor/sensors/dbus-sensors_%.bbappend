PACKAGECONFIG:remove = " \
    exitairtempsensor \
    mcutempsensor \
    psusensor \
"