OBMC_IMAGE_EXTRA_INSTALL:append:devkit2700 = " \
    adcapp \
    pwmtachtool \
    entity-manager \
    dbus-sensors \
    phosphor-pid-control \
    x86-power-control \
    bmcweb \
    webui-vue \
    phosphor-ipmi-kcs \
    phosphor-ipmi-net \
    phosphor-ipmi-ipmb \
    phosphor-user-manager \
    phosphor-network \
    obmc-console \
    obmc-ikvm \
    jsnbd \
    default-fru \
"