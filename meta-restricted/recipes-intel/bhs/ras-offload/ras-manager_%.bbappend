FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += " file://0001-Remove-TPMI-Support-From-Ras.patch"
