FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRCREV ="22c1c7848b46745e53b2ea13678cec112eba49cc"

SRC_URI += "file://0001-Add-DCMI-command-handler-support.patch "

